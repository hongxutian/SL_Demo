# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Fire_RT-Thread (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_RT-Thread +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\rtthread\3.0.3\components\finsh;..\..\rtthread\3.0.3\include;..\..\rtthread\3.0.3\include\libc;..\..\User\Bsp\led;..\..\User\Bsp\key;..\..\User\Bsp\uart;..\..\User\Bsp\exti;..\..\User\Bsp\g4;..\..\User\Bsp\oled;..\..\User\Bsp\display;..\..\User\Bsp\flash;..\..\User\Bsp\FATFS;..\..\User\Bsp\rtc;..\..\User\Bsp\fpm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: board.c rtconfig.h main.c stm32f10x_conf.h stm32f10x_it.h
    ../../User/Bsp/led/: bsp_led.c
    ../../User/Bsp/uart/: bsp_usart.c
    ../../User/Bsp/flash/: sysinit.c
    ../../User/Bsp/rtc/: bsp_rtc.c
    ../../User/Bsp/fpm/: fpm.c
  group DOC
    ../../Doc/: readme.txt
  group rtt/source
    ../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../../rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group g4
    ../../User/Bsp/g4/: AES.c base64.c cJSON.c CRC.c G4.c G4App.c myaes.c
  group display
    ../../User/Bsp/oled/: OLED_I2C.c
    ../../User/Bsp/display/: main_page.c UI.c key.c menu_page.c bind_device_page.c query_user_page.c modify_manager_password_page.c add_gen_password_page.c manage_gen_password_page.c msg_page.c add_user_page.c
  group FATFS
    ../../User/Bsp/flash/: bsp_spi_flash.c
    ../../User/Bsp/FATFS/: diskio.c ff.c
    ../../User/Bsp/FATFS/option/: cc936.c syscall.c
